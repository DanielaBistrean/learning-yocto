INITRAMFS_IMAGE = "my-core-image"
